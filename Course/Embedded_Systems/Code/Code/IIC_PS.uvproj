# Keil uVision project IIC_PS.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: IIC_PS +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Config;.\Driver;.\Device;.\Library
  link misc: REMOVEUNUSED
  group main
    ./: main.c
  group Library
    ./Library/: STC8G_H_GPIO.c STC8G_H_I2C.c STC8G_H_I2C_Isr.c STC8G_H_NVIC.c STC8G_H_Soft_I2C.c STC8G_H_Timer.c STC8G_H_Timer_Isr.c STC8G_H_UART.c STC8G_H_UART_Isr.c STC8G_H_ADC.c
  group User/Driver
    ./Driver/: driver.c driver.h iic_drv.c iic_drv.h
  group User/Device
    ./Device/: oled.c oled.h oled_font.h
  group User/Config
    ./Config/: config.h Type_def.h
