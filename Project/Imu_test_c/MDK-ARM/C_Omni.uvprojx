# Keil uVision project C_Omni.uvprojx, settings and files
target C_Omni (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: C_Omni +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1U,ARM_MATH_CM4,__CC_ARM,__TARGET_FPU_VFP
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User/Task;../User/Config;../User/Driver;../User/Device;../User/Module;../User/Protocol;../User/Algorithm;../User/Device/IMU;../User/Device/IMU/DSP;../User/Device/IMU/RP_IMU;../User/Device/IMU/RP_IMU/IMU;../User/Device/IMU/CMSIS/DSP/Include;../User/Support
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c freertos.c dma.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group User/Config
    ../User/Config/: type.h rp_config.h user_config.h drivers_config.h devices_config.h THE_BEST_BLESS_FOR_RPers.h
  group User/Algorithm
    ../User/Algorithm/: crc.c crc.h power_limit.c power_limit.h rp_math.c rp_math.h
  group User/Task
    ../User/Task/: control_task.c control_task.h monitor_task.c monitor_task.h system_task.c system_task.h
  group User/Module
    ../User/Module/: chassis.c chassis.h gimbal.c gimbal.h infantry.c infantry.h launch.c launch.h module.c module.h
  group User/Device
    ../User/Device/: device.c device.h judge.c judge.h judge_def.h motor.c motor.h motor_def.h rc_sensor.c rc_sensor.h slave.c slave.h vision.c vision.h
  group User/Device/IMU
    ../User/Device/IMU/RP_IMU/: imu.c
    ../User/Device/IMU/RP_IMU/IMU/: bmi.c BMI088driver.c BMI088Middleware.c
  group User/Protocol
    ../User/Protocol/: can_protocol.c can_protocol.h judge_protocol.c judge_protocol.h rc_protocol.c rc_protocol.h vision_protocol.c vision_protocol.h
  group User/Driver
    ../User/Driver/: can_drv.c can_drv.h driver.c driver.h gpio_drv.c gpio_drv.h haltick_drv.c haltick_drv.h spi_drv.c spi_drv.h uart_drv.c uart_drv.h
  group CMSIS/DSP
    ../User/Device/IMU/DSP/: arm_abs_f16.c arm_abs_f32.c arm_abs_f64.c arm_abs_q7.c arm_abs_q15.c arm_abs_q31.c arm_add_f16.c arm_add_f32.c arm_add_f64.c arm_add_q7.c arm_add_q15.c arm_add_q31.c arm_and_u8.c arm_and_u16.c arm_and_u32.c arm_atan2_f16.c arm_atan2_f32.c arm_atan2_q15.c arm_atan2_q31.c arm_clip_f16.c arm_clip_f32.c arm_clip_q7.c arm_clip_q15.c arm_clip_q31.c arm_common_tables.c arm_common_tables_f16.c arm_const_structs.c arm_const_structs_f16.c arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_divide_q15.c arm_divide_q31.c arm_dot_prod_f16.c arm_dot_prod_f32.c arm_dot_prod_f64.c arm_dot_prod_q7.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_mat_init_f32.c arm_mat_mult_f32.c arm_mat_trans_f32.c arm_mult_f16.c arm_mult_f32.c arm_mult_f64.c arm_mult_q7.c arm_mult_q15.c arm_mult_q31.c arm_mve_tables.c arm_mve_tables_f16.c arm_negate_f16.c arm_negate_f32.c arm_negate_f64.c arm_negate_q7.c arm_negate_q15.c arm_negate_q31.c arm_not_u8.c arm_not_u16.c arm_not_u32.c arm_offset_f16.c arm_offset_f32.c arm_offset_f64.c arm_offset_q7.c arm_offset_q15.c arm_offset_q31.c arm_or_u8.c arm_or_u16.c arm_or_u32.c arm_scale_f16.c arm_scale_f32.c arm_scale_f64.c arm_scale_q7.c arm_scale_q15.c arm_scale_q31.c arm_shift_q7.c arm_shift_q15.c arm_shift_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c arm_sub_f16.c arm_sub_f32.c arm_sub_f64.c arm_sub_q7.c arm_sub_q15.c arm_sub_q31.c arm_vexp_f16.c arm_vexp_f32.c arm_vexp_f64.c arm_vinverse_f16.c arm_vlog_f16.c arm_vlog_f32.c arm_vlog_f64.c arm_vlog_q15.c arm_vlog_q31.c arm_xor_u8.c arm_xor_u16.c arm_xor_u32.c CommonTables.c CommonTablesF16.c
  group User/Support
    ../User/Support/: ave_filter.c dji_pid.c math_support.c my_pid.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
software components: CMSIS:CORE 4.3.0
